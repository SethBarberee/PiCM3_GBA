File: Display.kicad_sch (KiCad schematic)
At the start: 6 parts

Commit message: slight updates
Connections:
- net 3V3 renamed CM_3V3
- no-connect marks 6 -> 7
